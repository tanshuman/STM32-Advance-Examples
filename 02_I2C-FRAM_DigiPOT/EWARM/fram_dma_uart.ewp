# IAR project fram_dma_uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F071VB ST STM32F071VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX_HD
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../CMSIS; ../Manual_Config; ../Std_Periph; ../user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fram_dma_uart.bin
  ILINK.IlinkOutputFile: fram_dma_uart.out
  ILINK.IlinkIcfFile: C:\Users\masta\Documents\Projects\OGH\FRAM\EWARM\stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: startup_stm32f0xx.s system_stm32f0xx.c
  group Std_Periph
    ../Std_Periph/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c
  group user
    ../user/: i2c_user.c main.c uart_user.c user_config.c
